# Repository Tecsmith/sr99-keyboard-pcb

File README.md:

# SR99-Keyboard-PCB

> :warning: **WIP:** Work in Progress design, and is not tested.  Please hold-off on building until the design can be verified and the software is written.

## Intent

A 980-layout (99-key) compact near-full size keyboard.

## Progression

> :bangbang: This is a "when I'm bored" project - so "significant" progress is not expected.

- **12 Jun 2026**
  - KiCAD 10 re-do done, but not built
- **15 Nov 2025**: Re-do begins!
  - EAGLE design abandoned in favour of KiCAD design
  - `STM32F411` discarded for **`STM32G474`**
- ~~**27 Sep 2024**: Beta 1 done~~
  - ~~:warning: Not manufactured~~
  - ~~:warning: Not tested~~
- See [CHANGELOG.md](CHANGELOG.md)

<!--
### Resources

 - Schematic PDF [here](docs/sr99-revXXX.pdf)
 - EAGLE BRD *(PCB)* [here](EAGLE/sr99/sr99-revXXX.brd)
 - EAGLE SCH *(Schematic)* [here](EAGLE/sr99/sr99-revXXX.sch)
-->

### Beta PCB renders

#### Top

#### Bottom *(Component side)*

◊
### Layout ideation renders

#### Render

#### Layout

#### Matrix coordinates *(QMK & VIA)*

## Planned Features

- [ ] QMK build, with Via/l support
- [x] 1x `STM32G474` STM32 CPU *(based on Black Pill design)*
- [x] 1x `M95640-DRE` 8K SPI EEPROM Module
- [x] 3x `MC74HC589A` SPI Input Shift Registers *- possibly faster scan rates*
- [x] 2x `IS31FL3743B` RGB Drivers, with independent LDOs
- [ ] 2x SKYLOONG rotary encoder/switch positions
- [x] UDB C-Series Usb-C JST-SH

<!--
#### Addons / Wishlist

- [ ] DIP Switch daughter board *(4-position)*
- [ ] ~~Case slide switch daughter board *(Win/Mac 2-state, + USB+BT+2.4GHz 3-state)*~~ *(To do)*
- [ ] USB 2.0 Hub
-->

<!--
## Wishlist

- [ ] Drop in replacement PCB *(e.g. compatible standoff positions)* for:
    - Brutal v2 1800
    - Monsgeek M2
    - ~~Skyloong GK980~~ *(The GK980 has a 0.5U gap between Esc and F1, making it not the same footprint as the B1k8 and M2.)*
-->

---

Made with :heart: by [**Silvino R**](https://github.com/silvinor)

## EAGLE design EAGLE/sr99/sr99-revA.brd

Parts:
C11: 22uF; C0603
C12, C13, C14, C15: 100nF; C0603
C16, C17: 4.3pF; C0603
C18, C19: 12pF; C0603
C20, C23: 22uF; 0603
C21, C22, C25, C26, C27, C28: 100nF; 0603
C24: 4.7uF; 0603
D00: B5819W SL; SOD-123
D107: BLUE; LED-RM-MILL
EEPROM: M25CDUAL; 8-SOIC-SO8_N_W_DUAL
L1: 10uH ±10%; L3225M
LM1117: AMS1117-3.3; SOT223
M_M2: SM05B-SRSS-TB(LF)(SN); CONN5_SM05B-SRSS_JST
Q1: 2N7002; SOT23-3
R0, R1, R2, R3, R4, R5: 10K; R0603X4
R45, R46: 10R; R0603
R65: 5.1K; R0603
R66: 10K; R0603
R70: 1K; R0603
TP-3V3, TP-5V: TEST-POINT.3SQ; PAD.03X.03-SQ
TP-GND: TEST-POINT.3SQ; PAD.03X.03-SQ
TP-USB+: TEST-POINT.3SQ; PAD.03X.03-SQ
TP-USB-: TEST-POINT.3SQ; PAD.03X.03-SQ
U1: STM32F411CEU7THERM; UFQFPN-48_7X7X0P55MM-THERM
U2, U3, U4: 74HC589A_DT; TSSOP16
UDB1: UBD-S1_C4; MOLEX_781710004
UDB2: UBD-C3; JST_SM04B-SRSS-TB_LF_SN
Y1: 32.768kHz ±20ppm 6pF; CRYSTAL-SMD-3.2X1.5MM
Y2: 25MHz 9pF; CRYSTAL_2.5X2

Connections:
!RESET: U1.7 (!RST); also elsewhere on the board
AUX_CS: U1.19 (PB1); also elsewhere on the board
AUX_DC: U1.11 (PA1); also elsewhere on the board
BOOT0: U1.44 (BOOT0); also elsewhere on the board
BOOT1: R66.2, U1.20 (PB2)
COL0: R4.7, U2.1 (B); also elsewhere on the board
COL1: R4.6, U2.2 (C); also elsewhere on the board
COL2: R4.5, U2.3 (D); also elsewhere on the board
COL3: R5.8, U2.4 (E); also elsewhere on the board
COL4: R5.7, U2.5 (F); also elsewhere on the board
COL5: R5.6, U2.6 (G); also elsewhere on the board
COL6: R5.5, U2.7 (H); also elsewhere on the board
COL7: R2.7, U3.1 (B); also elsewhere on the board
COL8: R2.6, U3.2 (C); also elsewhere on the board
COL9: R2.5, U3.3 (D); also elsewhere on the board
COL10: R3.8, U3.4 (E); also elsewhere on the board
COL11: R3.7, U3.5 (F); also elsewhere on the board
COL12: R3.6, U3.6 (G); also elsewhere on the board
COL13: R3.5, U3.7 (H); also elsewhere on the board
COL14: R1.7, U4.1 (B); also elsewhere on the board
COL15: R1.6, U4.2 (C); also elsewhere on the board
COL16: R1.5, U4.3 (D); also elsewhere on the board
COL17: R0.8, U4.4 (E); also elsewhere on the board
EE_CS: EEPROM.1 (!CS), U1.18 (PB0)
ENC_A: U1.12 (PA2); also elsewhere on the board
ENC_B: U1.13 (PA3); also elsewhere on the board
ENC_C: U1.29 (PA8); also elsewhere on the board
ENC_D: U1.41 (PB5); also elsewhere on the board
G1: R4.8, U2.15 (A)
G2: R2.8, U3.15 (A)
G3: R1.8, U4.15 (A)
G4: R0.7, U4.5 (F)
G5: R0.6, U4.6 (G)
G6: R0.5, U4.7 (H)
GND: C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, EEPROM.4 (GND), LM1117.1 (ADJ), M_M2.1, M_M2.2, M_M2.6, M_M2.7, Q1.2 (S), R0.1, R0.2, R0.3, R0.4, R1.1, R1.2, R1.3, R1.4, R2.1, R2.2, R2.3, R2.4, R3.1, R3.2, R3.3, R3.4, R4.1, R4.2, R4.3, R4.4, R5.1, R5.2, R5.3, R5.4, R66.1, TP-GND.1, U1.1 (VBAT), U1.8 (VSSA), U1.23 (VSS_2), U1.35 (VSS_3), U1.47 (VSS), U1.49 (EPAD), U1.49@1 (EPAD), U1.49@2 (EPAD), U1.49@3 (EPAD), U1.49@4 (EPAD), U1.49@5 (EPAD), U1.49@6 (EPAD), U1.49@7 (EPAD), U1.49@8 (EPAD), U1.49@9 (EPAD), U1.49@10 (EPAD), U1.49@11 (EPAD), U1.49@12 (EPAD), U1.49@13 (EPAD), U1.49@14 (EPAD), U1.49@15 (EPAD), U1.49@16 (EPAD), U1.49@17 (EPAD), U1.49@18 (EPAD), U2.8 (GND), U2.14 (SA), U3.8 (GND), U4.8 (GND), UDB1.4 (GND)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; also elsewhere on the board
J_RST: U1.40 (PB4); also elsewhere on the board
J_TCK: U1.37 (PA14); also elsewhere on the board
J_TDI: U1.38 (PA15); also elsewhere on the board
J_TDO: U1.39 (PB3); also elsewhere on the board
J_TMS: U1.34 (PA13); also elsewhere on the board
LATCH: Q1.3 (D), R65.1, U2.12 (LATCH), U2.13 (SS/!PL), U3.12 (LATCH), U3.13 (SS/!PL), U4.12 (LATCH), U4.13 (SS/!PL)
LED: D107.C, U1.2 (PC13-ANTI_TAMP)
LED1_CS: U1.30 (PA9); also elsewhere on the board
LED2_CS: U1.31 (PA10); also elsewhere on the board
LED_PWR_EN: U1.21 (PB10); also elsewhere on the board
MATRIX_CS: Q1.1 (G), U1.14 (PA4), U2.10 (OE/!CS), U3.10 (OE/!CS), U4.10 (OE/!CS)
MISO: EEPROM.2 (DO), U1.16 (PA6), U4.9 (QH); also elsewhere on the board
MOSI: EEPROM.5 (DIO), U1.17 (PA7); also elsewhere on the board
unnamed: C11.1, U1.22 (VCAP1)
unnamed: D107.A, R70.2
ROW0: U1.25 (PB12); also elsewhere on the board
ROW1: U1.26 (PB13); also elsewhere on the board
ROW2: U1.27 (PB14); also elsewhere on the board
ROW3: U1.28 (PB15); also elsewhere on the board
ROW4: U1.45 (PB8); also elsewhere on the board
ROW5: U1.46 (PB9); also elsewhere on the board
SCK: EEPROM.6 (CLK), U1.15 (PA5), U2.11 (SC/SCK), U3.11 (SC/SCK), U4.11 (SC/SCK); also elsewhere on the board
SCL: U1.42 (PB6); also elsewhere on the board
SDA: U1.43 (PB7); also elsewhere on the board
U2_TO_U3: U2.9 (QH), U3.14 (SA)
U3_TO_U4: U3.9 (QH), U4.14 (SA)
USB_D_N: M_M2.3, R45.1, TP-USB-.1, UDB1.2 (DN), UDB2.2 (DN)
USB_D_P: M_M2.4, R46.1, TP-USB+.1, UDB1.3 (DP), UDB2.3 (DP)
USB_N: R45.2, U1.32 (PA11)
USB_P: R46.2, U1.33 (PA12)
VCC_1: C20.1, C21.1, D00.C, LM1117.3 (IN), M_M2.5, TP-5V.1, UDB1.1 (VCC), UDB2.1 (VCC); also elsewhere on the board
VCC_2: C13.1, C14.1, C15.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, D00.A, EEPROM.3 (!WP), EEPROM.7 (!HLD), EEPROM.8 (VCC), L1.2, LM1117.2 (OUT), LM1117.4 (OUT), R65.2, R70.1, TP-3V3.1, U1.24 (VDD_2), U1.36 (VDD_3), U1.48 (VDD), U2.16 (VCC), U3.16 (VCC), U4.16 (VCC); also elsewhere on the board
VREF+: C12.1, L1.1, U1.9 (VREF+)
WKUP: U1.10 (PA0-WKUP); also elsewhere on the board
Y1I: C16.1, U1.3 (PC14-OSC32_IN), Y1.P$2 (2)
Y1O: C17.1, U1.4 (PC15-OSC32_OUT), Y1.P$1 (1)
Y2I: C18.1, U1.5 (PH0-OSC_IN), Y2.3
Y2O: C19.1, U1.6 (PH1-OSC_OUT), Y2.1

Notes on the sheet:
DNP Unified Daughter Board (C3) Conn. (Legacy)
** NEW ** Unified Daughter Board (C4) Conn.
STM32F411 MCU (Pins)
STM32F411 MCU (Power)
5V to 3V3 Power Circuit
SPI EEPROM (Optional)
Column Scanner Shift Registers
BOOT1
Status LED
Shift/Reg Decoupling
Shift/Reg / Col-scan Pulldowns
Monsgeek M2 Drop-In Mounting Holes (marked with Triangle) and JST connector pinout stil need to be confirmed.
nBOOT1 - Select Boot Area 1 = System memory 0 = Embedded SRAM

Parts:
5V: CONN_02; 1X02
C29: 10uF; C0805
C30: 100nF; C0805
C31, C32, C35, C36: 100nF; C0603
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80, D81, D82, D83, D84, D85, D86, D87, D88, D89, D90, D91, D92, D93, D94, D95, D96, D97, D98, D99: 1N5819WS; SOD-123
D100: 1N4148; SOD-123
G1, G2, G3, G4, G5, G6: MGEEK-M2-HOLE
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10, H11, H12: BRURAL-1800-HOLE; BRUTAL-1800-HOLE
H_BSP: MX-STABS-200U
H_ENT: MX-STABS-200U
H_LS: MX-STABS-200U
H_NEN: MX-STABS-200U
H_NP: MX-STABS-200U
H_SPC: MX-STABS-625U
JDIP: MOLEX_0781710006; MOLEX_781710006
JI2C: CONN_04; 1X04
JPWM: CONN_05NO_SILK; 1X05_NO_SILK
JSPI: DNP; 2X3-NS
JSPI@2: CONN_01; 1X01
JTAG: TC2050IDC-NL; TC2050-IDC-NL
LOGO1: OSHW-LOGOL; OSHW-LOGO-L
Q2, Q3, Q7: 2N7002; SOT23-3
Q4, Q5: AO3401A; SOT-23-3L_AOS
Q6: BSH201; SOT23-3
R16, R17, R30, R31: 5.1K; R0603
R18, R19, R22, R23, R27, R32: 10K; R0603
R20: 330K; R0603
R21: 1M; R0603
R24, R28, R29: 100K; R0603
R25: 100R; R0603
R26: 1K; R0603
R33@1: 0R; R0805W
R33@2, R34: 0R-DNP; R0805W
RST: CONN_02; 1X02
S1: Reset; TACTILE_SWITCH_SMD_5.2MM
SW_0, SW_1, SW_2, SW_3, SW_4, SW_5, SW_6, SW_7, SW_8, SW_9: MX-5-PIN-HOTSWAP-PAD
SW_A: MX-5-PIN-HOTSWAP-PAD
SW_B: MX-5-PIN-HOTSWAP-PAD
SW_BSP: MX-5-PIN-HOTSWAP-PAD
SW_C: MX-5-PIN-HOTSWAP-PAD
SW_CB: MX-5-PIN-HOTSWAP-PAD
SW_CL: MX-5-PIN-HOTSWAP-PAD
SW_CM: MX-5-PIN-HOTSWAP-PAD
SW_CS: MX-5-PIN-HOTSWAP-PAD
SW_D: MX-5-PIN-HOTSWAP-PAD
SW_DN: MX-5-PIN-HOTSWAP-PAD
SW_DP: MX-5-PIN-HOTSWAP-PAD
SW_DSH: MX-5-PIN-HOTSWAP-PAD
SW_DT: MX-5-PIN-HOTSWAP-PAD
SW_E: MX-5-PIN-HOTSWAP-PAD
SW_ENT: MX-5-PIN-HOTSWAP-PAD
SW_EP: MX-5-PIN-HOTSWAP-PAD
SW_ESC: MX-5-PIN-HOTSWAP-PAD
SW_F, SW_F1, SW_F2, SW_F3, SW_F4, SW_F5, SW_F6, SW_F7, SW_F8, SW_F9, SW_F10, SW_F11, SW_F12, SW_F14, SW_F15, SW_F16: MX-5-PIN-HOTSWAP-PAD
SW_F13, SW_F17: MX-5-PIN-SKYLOONG-KNOB
SW_FS: MX-5-PIN-HOTSWAP-PAD
SW_G: MX-5-PIN-HOTSWAP-PAD
SW_H: MX-5-PIN-HOTSWAP-PAD
SW_I: MX-5-PIN-HOTSWAP-PAD
SW_J: MX-5-PIN-HOTSWAP-PAD
SW_K: MX-5-PIN-HOTSWAP-PAD
SW_L: MX-5-PIN-HOTSWAP-PAD
SW_LA: MX-5-PIN-HOTSWAP-PAD
SW_LC: MX-5-PIN-HOTSWAP-PAD
SW_LF: MX-5-PIN-HOTSWAP-PAD
SW_LS: MX-5-PIN-HOTSWAP-PAD
SW_LW: MX-5-PIN-HOTSWAP-PAD
SW_M: MX-5-PIN-HOTSWAP-PAD
SW_MIN: MX-5-PIN-HOTSWAP-PAD
SW_MU: MX-5-PIN-HOTSWAP-PAD
SW_MUL: MX-5-PIN-HOTSWAP-PAD
SW_N, SW_N0, SW_N1, SW_N2, SW_N3, SW_N4, SW_N5, SW_N6, SW_N7, SW_N8, SW_N9: MX-5-PIN-HOTSWAP-PAD
SW_ND: MX-5-PIN-HOTSWAP-PAD
SW_NEN: MX-5-PIN-HOTSWAP-PAD
SW_NP: MX-5-PIN-HOTSWAP-PAD
SW_NUM: MX-5-PIN-HOTSWAP-PAD
SW_O: MX-5-PIN-HOTSWAP-PAD
SW_OB: MX-5-PIN-HOTSWAP-PAD
SW_P: MX-5-PIN-HOTSWAP-PAD
SW_Q: MX-5-PIN-HOTSWAP-PAD
SW_QU: MX-5-PIN-HOTSWAP-PAD
SW_R: MX-5-PIN-HOTSWAP-PAD
SW_RA: MX-5-PIN-HOTSWAP-PAD
SW_RC: MX-5-PIN-HOTSWAP-PAD
SW_RS: MX-5-PIN-HOTSWAP-PAD
SW_RT: MX-5-PIN-HOTSWAP-PAD
SW_RW: MX-5-PIN-HOTSWAP-PAD
SW_S: MX-5-PIN-HOTSWAP-PAD
SW_SPC: MX-5-PIN-HOTSWAP-PAD
SW_T: MX-5-PIN-HOTSWAP-PAD
SW_TAB: MX-5-PIN-HOTSWAP-PAD
SW_TDL: MX-5-PIN-HOTSWAP-PAD
SW_U: MX-5-PIN-HOTSWAP-PAD
SW_UP: MX-5-PIN-HOTSWAP-PAD
SW_V: MX-5-PIN-HOTSWAP-PAD
SW_W: MX-5-PIN-HOTSWAP-PAD
SW_X: MX-5-PIN-HOTSWAP-PAD
SW_Y: MX-5-PIN-HOTSWAP-PAD
SW_Z: MX-5-PIN-HOTSWAP-PAD
U$1, U$2, U$3: FIDUCIAL
U$4: QMK_LOGO
U$5: TECSMITH-LOGOLONG; TECSMITH-NAME

Connections:
!BOOT: Q6.1 (G), R28.2, RST.2, S1.3 (2), S1.4 (2)
!RESET: C30.2, R25.2; also elsewhere on the board
AUX_CS: JPWM.4, JSPI.5; also elsewhere on the board
AUX_DC: JPWM.3, JSPI@2.1; also elsewhere on the board
BOOT: D100.A, Q6.3 (D), R26.2, R29.2
BOOT0: C29.1, R20.1, R21.2, R22.2; also elsewhere on the board
COL0: D1.C, D19.C, D37.C, D55.C, D71.C, D88.C; also elsewhere on the board
COL1: D2.C, D20.C, D38.C, D56.C, D89.C; also elsewhere on the board
COL2: D3.C, D21.C, D39.C, D57.C, D72.C, D90.C; also elsewhere on the board
COL3: D4.C, D22.C, D40.C, D58.C, D73.C, JDIP.3; also elsewhere on the board
COL4: D5.C, D23.C, D41.C, D59.C, D74.C, JDIP.4; also elsewhere on the board
COL5: D6.C, D24.C, D42.C, D60.C, D75.C, D91.C; also elsewhere on the board
COL6: D7.C, D25.C, D43.C, D61.C, D76.C, JDIP.5; also elsewhere on the board
COL7: D8.C, D26.C, D44.C, D62.C, D77.C, JDIP.6; also elsewhere on the board
COL8: D9.C, D27.C, D45.C, D63.C, D78.C, D92.C; also elsewhere on the board
COL9: D10.C, D28.C, D46.C, D64.C, D79.C, D93.C; also elsewhere on the board
COL10: D11.C, D29.C, D47.C, D65.C, D80.C, D94.C; also elsewhere on the board
COL11: D12.C, D30.C, D48.C, D66.C, D81.C, D95.C; also elsewhere on the board
COL12: D13.C, D31.C, D49.C, D82.C, D96.C; also elsewhere on the board
COL13: D14.C, D32.C, D50.C, D67.C, D83.C, D97.C; also elsewhere on the board
COL14: D15.C, D33.C, D51.C, D68.C, D84.C; also elsewhere on the board
COL15: D16.C, D34.C, D52.C, D69.C, D85.C, D98.C; also elsewhere on the board
COL16: D17.C, D35.C, D53.C, D70.C, D86.C, D99.C; also elsewhere on the board
COL17: D18.C, D36.C, D54.C, D87.C; also elsewhere on the board
D91_A: D91.A, Q7.2 (S), R34.2
ENC_A: C35.1, R16.1, SW_F13.A; also elsewhere on the board
ENC_B: C36.1, R17.1, SW_F13.B; also elsewhere on the board
ENC_C: C31.1, R30.1, SW_F17.A; also elsewhere on the board
ENC_D: C32.1, R31.1, SW_F17.B; also elsewhere on the board
GND: 5V.2, C29.2, C30.1, C31.2, C32.2, C35.2, C36.2, JDIP.1, JI2C.4, JPWM.5, JSPI.6, JTAG.3 (GND), JTAG.5 (GND), JTAG.9 (GND), Q2.2 (S), Q3.2 (S), R21.1, R24.2, R27.2, R29.1, R32.2, RST.1, S1.1, S1.2 (1), SW_F13.C, SW_F17.C; also elsewhere on the board
J_RST: JTAG.10 (!RESET); also elsewhere on the board
J_TCK: JTAG.2 (SWDIO/TMS); also elsewhere on the board
J_TDI: JTAG.8 (TDI); also elsewhere on the board
J_TDO: JTAG.6 (SWO/TDO); also elsewhere on the board
J_TMS: JTAG.4 (SWCLK/TCK); also elsewhere on the board
K_BSP: D32.A, SW_BSP.1@1, SW_BSP.1@2
K_CL1: D55.A, SW_CL.1@1, SW_CL.1@2
K_DP: D50.A, SW_DP.1@1, SW_DP.1@2
K_ENT: D67.A, SW_ENT.1@1, SW_ENT.1@2
K_LS: D71.A, SW_LS.1@1, SW_LS.1@2
MISO: JSPI.1; also elsewhere on the board
MOSI: JSPI.4; also elsewhere on the board
unnamed: D70.A, SW_N6.1@1, SW_N6.1@2
unnamed: R33@1.2, R33@2.1, SW_SPC.2@1 (S), SW_SPC.2@2 (S)
unnamed: D100.C, R20.2
unnamed: Q5.1 (G), R19.1, SW_F17.S
unnamed: Q3.3 (D), R22.1
unnamed: Q4.1 (G), R18.1, SW_F13.S
unnamed: Q3.1 (G), R23.1, R24.1
unnamed: Q2.3 (D), R23.2, R25.1
unnamed: Q2.1 (G), R26.1, R27.1
unnamed: D1.A, SW_ESC.1@1, SW_ESC.1@2
unnamed: D2.A, SW_F1.1@1, SW_F1.1@2
unnamed: D3.A, SW_F2.1@1, SW_F2.1@2
unnamed: D4.A, SW_F3.1@1, SW_F3.1@2
unnamed: D5.A, SW_F4.1@1, SW_F4.1@2
unnamed: D6.A, SW_F5.1@1, SW_F5.1@2
unnamed: D7.A, SW_F6.1@1, SW_F6.1@2
unnamed: D8.A, SW_F7.1@1, SW_F7.1@2
unnamed: D9.A, SW_F8.1@1, SW_F8.1@2
unnamed: D10.A, SW_F9.1@1, SW_F9.1@2
unnamed: D11.A, SW_F10.1@1, SW_F10.1@2
unnamed: D12.A, SW_F11.1@1, SW_F11.1@2
unnamed: D13.A, SW_F12.1@1, SW_F12.1@2
unnamed: D15.A, SW_F14.1@1, SW_F14.1@2
unnamed: D16.A, SW_F15.1@1, SW_F15.1@2
unnamed: D19.A, SW_TDL.1@1, SW_TDL.1@2
unnamed: D20.A, SW_1.1@1, SW_1.1@2
unnamed: D21.A, SW_2.1@1, SW_2.1@2
unnamed: D22.A, SW_3.1@1, SW_3.1@2
unnamed: D23.A, SW_4.1@1, SW_4.1@2
unnamed: D24.A, SW_5.1@1, SW_5.1@2
unnamed: D25.A, SW_6.1@1, SW_6.1@2
unnamed: D26.A, SW_7.1@1, SW_7.1@2
unnamed: D27.A, SW_8.1@1, SW_8.1@2
unnamed: D28.A, SW_9.1@1, SW_9.1@2
unnamed: D29.A, SW_0.1@1, SW_0.1@2
unnamed: D30.A, SW_MU.1@1, SW_MU.1@2
unnamed: D31.A, SW_EP.1@1, SW_EP.1@2
unnamed: D33.A, SW_NUM.1@1, SW_NUM.1@2
unnamed: D34.A, SW_DSH.1@1, SW_DSH.1@2
unnamed: D38.A, SW_Q.1@1, SW_Q.1@2
unnamed: D37.A, SW_TAB.1@1, SW_TAB.1@2
unnamed: D39.A, SW_W.1@1, SW_W.1@2
unnamed: D40.A, SW_E.1@1, SW_E.1@2
unnamed: D41.A, SW_R.1@1, SW_R.1@2
unnamed: D42.A, SW_T.1@1, SW_T.1@2
unnamed: D43.A, SW_Y.1@1, SW_Y.1@2
unnamed: D44.A, SW_U.1@1, SW_U.1@2
unnamed: D45.A, SW_I.1@1, SW_I.1@2
unnamed: D46.A, SW_O.1@1, SW_O.1@2
unnamed: D47.A, SW_P.1@1, SW_P.1@2
unnamed: D48.A, SW_OB.1@1, SW_OB.1@2
unnamed: D49.A, SW_CB.1@1, SW_CB.1@2
unnamed: D51.A, SW_N7.1@1, SW_N7.1@2
unnamed: D52.A, SW_N8.1@1, SW_N8.1@2
unnamed: D69.A, SW_N5.1@1, SW_N5.1@2
unnamed: D68.A, SW_N4.1@1, SW_N4.1@2
unnamed: D66.A, SW_QU.1@1, SW_QU.1@2
unnamed: D65.A, SW_CS.1@1, SW_CS.1@2
unnamed: D64.A, SW_L.1@1, SW_L.1@2
unnamed: D56.A, SW_A.1@1, SW_A.1@2
unnamed: D57.A, SW_S.1@1, SW_S.1@2
unnamed: D58.A, SW_D.1@1, SW_D.1@2
unnamed: D59.A, SW_F.1@1, SW_F.1@2
unnamed: D60.A, SW_G.1@1, SW_G.1@2
unnamed: D61.A, SW_H.1@1, SW_H.1@2
unnamed: D62.A, SW_J.1@1, SW_J.1@2
unnamed: D63.A, SW_K.1@1, SW_K.1@2
unnamed: D72.A, SW_Z.1@1, SW_Z.1@2
unnamed: D73.A, SW_X.1@1, SW_X.1@2
unnamed: D74.A, SW_C.1@1, SW_C.1@2
unnamed: D75.A, SW_V.1@1, SW_V.1@2
unnamed: D76.A, SW_B.1@1, SW_B.1@2
unnamed: D77.A, SW_N.1@1, SW_N.1@2
unnamed: D78.A, SW_M.1@1, SW_M.1@2
unnamed: D79.A, SW_CM.1@1, SW_CM.1@2
unnamed: D80.A, SW_DT.1@1, SW_DT.1@2
unnamed: D81.A, SW_FS.1@1, SW_FS.1@2
unnamed: D82.A, SW_RS.1@1, SW_RS.1@2
unnamed: D83.A, SW_UP.1@1, SW_UP.1@2
unnamed: D84.A, SW_N1.1@1, SW_N1.1@2
unnamed: D85.A, SW_N2.1@1, SW_N2.1@2
unnamed: D98.A, SW_N0.1@1, SW_N0.1@2
unnamed: D97.A, SW_RT.1@1, SW_RT.1@2
unnamed: D96.A, SW_DN.1@1, SW_DN.1@2
unnamed: D95.A, SW_LF.1@1, SW_LF.1@2
unnamed: D94.A, SW_RC.1@1, SW_RC.1@2
unnamed: D93.A, SW_RW.1@1, SW_RW.1@2
unnamed: D92.A, SW_RA.1@1, SW_RA.1@2
unnamed: D90.A, SW_LA.1@1, SW_LA.1@2
unnamed: D89.A, SW_LW.1@1, SW_LW.1@2
unnamed: D88.A, SW_LC.1@1, SW_LC.1@2
unnamed: D99.A, SW_ND.1@1, SW_ND.1@2
unnamed: D86.A, SW_N3.1@1, SW_N3.1@2
unnamed: D87.A, SW_NEN.2@1 (S), SW_NEN.2@2 (S)
unnamed: D54.A, SW_NP.2@1 (S), SW_NP.2@2 (S)
unnamed: D53.A, SW_N9.1@1, SW_N9.1@2
unnamed: D36.A, SW_MIN.1@1, SW_MIN.1@2
unnamed: D35.A, SW_MUL.1@1, SW_MUL.1@2
unnamed: D17.A, SW_F16.1@1, SW_F16.1@2
ROW0: Q4.2 (S), Q5.2 (S), SW_ESC.2@1 (S), SW_ESC.2@2 (S), SW_F1.2@1 (S), SW_F1.2@2 (S), SW_F2.2@1 (S), SW_F2.2@2 (S), SW_F3.2@1 (S), SW_F3.2@2 (S), SW_F4.2@1 (S), SW_F4.2@2 (S), SW_F5.2@1 (S), SW_F5.2@2 (S), SW_F6.2@1 (S), SW_F6.2@2 (S), SW_F7.2@1 (S), SW_F7.2@2 (S), SW_F8.2@1 (S), SW_F8.2@2 (S), SW_F9.2@1 (S), SW_F9.2@2 (S), SW_F10.2@1 (S), SW_F10.2@2 (S), SW_F11.2@1 (S), SW_F11.2@2 (S), SW_F12.2@1 (S), SW_F12.2@2 (S), SW_F13.2@1 (S), SW_F13.2@2 (S), SW_F14.2@1 (S), SW_F14.2@2 (S), SW_F15.2@1 (S), SW_F15.2@2 (S), SW_F16.2@1 (S), SW_F16.2@2 (S), SW_F17.2@1 (S), SW_F17.2@2 (S); also elsewhere on the board
ROW1: SW_0.2@1 (S), SW_0.2@2 (S), SW_1.2@1 (S), SW_1.2@2 (S), SW_2.2@1 (S), SW_2.2@2 (S), SW_3.2@1 (S), SW_3.2@2 (S), SW_4.2@1 (S), SW_4.2@2 (S), SW_5.2@1 (S), SW_5.2@2 (S), SW_6.2@1 (S), SW_6.2@2 (S), SW_7.2@1 (S), SW_7.2@2 (S), SW_8.2@1 (S), SW_8.2@2 (S), SW_9.2@1 (S), SW_9.2@2 (S), SW_BSP.2@1 (S), SW_BSP.2@2 (S), SW_DSH.2@1 (S), SW_DSH.2@2 (S), SW_EP.2@1 (S), SW_EP.2@2 (S), SW_MIN.2@1 (S), SW_MIN.2@2 (S), SW_MU.2@1 (S), SW_MU.2@2 (S), SW_MUL.2@1 (S), SW_MUL.2@2 (S), SW_NUM.2@1 (S), SW_NUM.2@2 (S), SW_TDL.2@1 (S), SW_TDL.2@2 (S); also elsewhere on the board
ROW2: SW_CB.2@1 (S), SW_CB.2@2 (S), SW_DP.2@1 (S), SW_DP.2@2 (S), SW_E.2@1 (S), SW_E.2@2 (S), SW_I.2@1 (S), SW_I.2@2 (S), SW_N7.2@1 (S), SW_N7.2@2 (S), SW_N8.2@1 (S), SW_N8.2@2 (S), SW_N9.2@1 (S), SW_N9.2@2 (S), SW_NP.1@1, SW_NP.1@2, SW_O.2@1 (S), SW_O.2@2 (S), SW_OB.2@1 (S), SW_OB.2@2 (S), SW_P.2@1 (S), SW_P.2@2 (S), SW_Q.2@1 (S), SW_Q.2@2 (S), SW_R.2@1 (S), SW_R.2@2 (S), SW_T.2@1 (S), SW_T.2@2 (S), SW_TAB.2@1 (S), SW_TAB.2@2 (S), SW_U.2@1 (S), SW_U.2@2 (S), SW_W.2@1 (S), SW_W.2@2 (S), SW_Y.2@1 (S), SW_Y.2@2 (S); also elsewhere on the board
ROW3: SW_A.2@1 (S), SW_A.2@2 (S), SW_CL.2@1 (S), SW_CL.2@2 (S), SW_CS.2@1 (S), SW_CS.2@2 (S), SW_D.2@1 (S), SW_D.2@2 (S), SW_ENT.2@1 (S), SW_ENT.2@2 (S), SW_F.2@1 (S), SW_F.2@2 (S), SW_G.2@1 (S), SW_G.2@2 (S), SW_H.2@1 (S), SW_H.2@2 (S), SW_J.2@1 (S), SW_J.2@2 (S), SW_K.2@1 (S), SW_K.2@2 (S), SW_L.2@1 (S), SW_L.2@2 (S), SW_N4.2@1 (S), SW_N4.2@2 (S), SW_N5.2@1 (S), SW_N5.2@2 (S), SW_N6.2@1 (S), SW_N6.2@2 (S), SW_QU.2@1 (S), SW_QU.2@2 (S), SW_S.2@1 (S), SW_S.2@2 (S); also elsewhere on the board
ROW4: SW_B.2@1 (S), SW_B.2@2 (S), SW_C.2@1 (S), SW_C.2@2 (S), SW_CM.2@1 (S), SW_CM.2@2 (S), SW_DT.2@1 (S), SW_DT.2@2 (S), SW_FS.2@1 (S), SW_FS.2@2 (S), SW_LS.2@1 (S), SW_LS.2@2 (S), SW_M.2@1 (S), SW_M.2@2 (S), SW_N.2@1 (S), SW_N.2@2 (S), SW_N1.2@1 (S), SW_N1.2@2 (S), SW_N2.2@1 (S), SW_N2.2@2 (S), SW_N3.2@1 (S), SW_N3.2@2 (S), SW_NEN.1@1, SW_NEN.1@2, SW_RS.2@1 (S), SW_RS.2@2 (S), SW_UP.2@1 (S), SW_UP.2@2 (S), SW_V.2@1 (S), SW_V.2@2 (S), SW_X.2@1 (S), SW_X.2@2 (S), SW_Z.2@1 (S), SW_Z.2@2 (S); also elsewhere on the board
ROW5: JDIP.2, Q7.3 (D), R33@2.2, SW_DN.2@1 (S), SW_DN.2@2 (S), SW_LA.2@1 (S), SW_LA.2@2 (S), SW_LC.2@1 (S), SW_LC.2@2 (S), SW_LF.2@1 (S), SW_LF.2@2 (S), SW_LW.2@1 (S), SW_LW.2@2 (S), SW_N0.2@1 (S), SW_N0.2@2 (S), SW_ND.2@1 (S), SW_ND.2@2 (S), SW_RA.2@1 (S), SW_RA.2@2 (S), SW_RC.2@1 (S), SW_RC.2@2 (S), SW_RT.2@1 (S), SW_RT.2@2 (S), SW_RW.2@1 (S), SW_RW.2@2 (S); also elsewhere on the board
S13: D14.A, Q4.3 (D), SW_F13.1@1, SW_F13.1@2
S17: D18.A, Q5.3 (D), SW_F17.1@1, SW_F17.1@2
SCK: JSPI.3; also elsewhere on the board
SCL: JI2C.1; also elsewhere on the board
SDA: JI2C.2; also elsewhere on the board
VCC_1: 5V.1; also elsewhere on the board
VCC_2: JI2C.3, JPWM.1, JSPI.2, JTAG.1 (VTREF), Q6.2 (S), R16.2, R17.2, R18.2, R19.2, R28.1, R30.2, R31.2, R33@1.1; also elsewhere on the board
WKUP: JPWM.2, Q7.1 (G), R32.1, R34.1, SW_SPC.1@1, SW_SPC.1@2; also elsewhere on the board

Notes on the sheet:
(Optional) DIP_SWITCH_2
DNP
Optional DIP Switch [Pico EzMate]
(Optional) DIP_SWITCH_3
Debug Header [TC2050-IDC]
Optional / Aux SPI break-out [0.1' PTH]
Optional I2C break-out [0.1' PTH]
Optional PWM break-out [0.1' PTH]
2x SKYLOONG Rotary Encoder positions
Hard Reset Ciruit
5V Test Pad [0.1' PTH]
(Optional) DIP_SWITCH_1
(Optional) DIP_SWITCH_4
DIP SWITCH 1 DIP SWITCH 2 DIP SWITCH 3 DIP SWITCH 4
Optional Rotary Encoder
Space as Wake Up circuit {{ !! EXPERIMENTAL !! }}

Notices in the files:
EAGLE/sr99/sr99-revA.brd:
(c) 2024 Silvino Rodrigues
EAGLE/vr99/dip-switch-daughter-brd-revA.brd:
(c) 2024 Vino Rodrigues
parts and their libraries:
SparkFun-Capacitors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
ts_custom_nick_nacks: ©2009 ROFA.cz
COPYRIGHT: Copyright (C) 2023 Ultra Librarian. All rights reserved.
COPYRIGHT: Copyright (C) 2024 Ultra Librarian. All rights reserved.
