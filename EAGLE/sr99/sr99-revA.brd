# Repository Tecsmith/sr99-keyboard-pcb (continued)

## EAGLE design EAGLE/sr99/sr99-revA.brd (continued)

Parts:
C1, C3, C6, C8, C33, C34: 1uF; C0603
C2, C4, C5, C7, C9, C10: 0.1uF; C0603
R6, R7, R8, R9, R10, R11: 20R; R0603X4
R12, R13, R14, R15: 51R; R0603X4
R37, R39: 100K; R0603
R38, R40: 10K; R0603
R41, R42: 4K7; R0603
R71, R72: 1K; R0603
TP-LED-EN: TEST-POINT.3SQ; PAD.03X.03-SQ
TP-V-LED-1, TP-V-LED-2: TEST-POINT.3SQ; PAD.03X.03-SQ
U5, U6: IS31FL3743B; UQFN40
U7, U8: TPS22995H-Q1; SOT-23-THIN-6_DDC_TEX
U$7: ??; JLC_ORDER_NUMBER_QR_8X8
Z1, Z2, Z3, Z4, Z5, Z6, Z7, Z8, Z9, Z10, Z11, Z12, Z13, Z14, Z15, Z16, Z17, Z18, Z20, Z21, Z22, Z23, Z24, Z25, Z26, Z27, Z28, Z29, Z30, Z31, Z32, Z33, Z34, Z35, Z36, Z37, Z38, Z39, Z40, Z41, Z42, Z43, Z44, Z45, Z46, Z47, Z48, Z49, Z50, Z51, Z52, Z53, Z54, Z55, Z56, Z57, Z58, Z59, Z60, Z61, Z62, Z63, Z64, Z65, Z66, Z67, Z68, Z69, Z70, Z71, Z72, Z73, Z74, Z75, Z76, Z77, Z78, Z79, Z80, Z81, Z82, Z83, Z84, Z85, Z86, Z87, Z88, Z89, Z90, Z91, Z92, Z93, Z94, Z95, Z96, Z97, Z98, Z99, Z101, Z102, Z103, Z104, Z105, Z106, Z107: 156120M173000MILL; 156120M173000-MILL
Z19: DNP; 156120M173000-MILL

Connections:
BLU1: R6.8, Z1.2 (B), Z2.2 (B), Z3.2 (B), Z4.2 (B), Z5.2 (B), Z6.2 (B), Z7.2 (B), Z8.2 (B), Z9.2 (B)
BLU2: R6.6, Z19.2 (B), Z20.2 (B), Z21.2 (B), Z22.2 (B), Z23.2 (B), Z24.2 (B), Z25.2 (B), Z26.2 (B), Z27.2 (B), Z28.2 (B)
BLU3: R7.6, Z37.2 (B), Z38.2 (B), Z39.2 (B), Z40.2 (B), Z41.2 (B), Z42.2 (B), Z43.2 (B), Z44.2 (B), Z45.2 (B)
BLU4: R7.8, Z55.2 (B), Z56.2 (B), Z57.2 (B), Z58.2 (B), Z59.2 (B), Z60.2 (B), Z61.2 (B), Z62.2 (B), Z63.2 (B)
BLU5: R8.8, Z71.2 (B), Z72.2 (B), Z73.2 (B), Z74.2 (B), Z75.2 (B), Z76.2 (B), Z77.2 (B), Z78.2 (B)
BLU6: R8.6, Z88.2 (B), Z89.2 (B), Z90.2 (B), Z91.2 (B), Z104.2 (B), Z105.2 (B), Z106.2 (B), Z107.2 (B)
BLU7: R9.8, Z10.2 (B), Z11.2 (B), Z12.2 (B), Z13.2 (B), Z14.2 (B), Z15.2 (B), Z16.2 (B), Z17.2 (B), Z18.2 (B)
BLU8: R9.6, Z29.2 (B), Z30.2 (B), Z31.2 (B), Z32.2 (B), Z33.2 (B), Z34.2 (B), Z35.2 (B), Z36.2 (B), Z101.2 (B), Z102.2 (B)
BLU9: R10.8, Z46.2 (B), Z47.2 (B), Z48.2 (B), Z49.2 (B), Z50.2 (B), Z51.2 (B), Z52.2 (B), Z53.2 (B), Z54.2 (B), Z103.2 (B)
BLU10: R10.6, Z64.2 (B), Z65.2 (B), Z66.2 (B), Z67.2 (B), Z68.2 (B), Z69.2 (B), Z70.2 (B)
BLU11: R11.8, Z79.2 (B), Z80.2 (B), Z81.2 (B), Z82.2 (B), Z83.2 (B), Z84.2 (B), Z85.2 (B), Z86.2 (B), Z87.2 (B)
BLU12: R11.6, Z92.2 (B), Z93.2 (B), Z94.2 (B), Z95.2 (B), Z96.2 (B), Z97.2 (B), Z98.2 (B), Z99.2 (B)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C33.1, C34.1, R12.4, R12.5, R13.1, R13.8, R14.4, R14.5, R15.1, R15.8, R37.1, R38.1, R39.1, R40.1, R71.1, R72.1, U5.16 (PGND), U5.23 (GND), U5.EPAD, U5.EPAD@1 (EPAD), U5.EPAD@2 (EPAD), U6.16 (PGND), U6.23 (GND), U6.EPAD, U6.EPAD@1 (EPAD), U6.EPAD@2 (EPAD), U7.4 (G), U8.4 (G); also elsewhere on the board
GRN1: R6.7, Z1.4 (G), Z2.4 (G), Z3.4 (G), Z4.4 (G), Z5.4 (G), Z6.4 (G), Z7.4 (G), Z8.4 (G), Z9.4 (G)
GRN2: R6.5, Z19.4 (G), Z20.4 (G), Z21.4 (G), Z22.4 (G), Z23.4 (G), Z24.4 (G), Z25.4 (G), Z26.4 (G), Z27.4 (G), Z28.4 (G)
GRN3: R7.5, Z37.4 (G), Z38.4 (G), Z39.4 (G), Z40.4 (G), Z41.4 (G), Z42.4 (G), Z43.4 (G), Z44.4 (G), Z45.4 (G)
GRN4: R7.7, Z55.4 (G), Z56.4 (G), Z57.4 (G), Z58.4 (G), Z59.4 (G), Z60.4 (G), Z61.4 (G), Z62.4 (G), Z63.4 (G)
GRN5: R8.7, Z71.4 (G), Z72.4 (G), Z73.4 (G), Z74.4 (G), Z75.4 (G), Z76.4 (G), Z77.4 (G), Z78.4 (G)
GRN6: R8.5, Z88.4 (G), Z89.4 (G), Z90.4 (G), Z91.4 (G), Z104.4 (G), Z105.4 (G), Z106.4 (G), Z107.4 (G)
GRN7: R9.7, Z10.4 (G), Z11.4 (G), Z12.4 (G), Z13.4 (G), Z14.4 (G), Z15.4 (G), Z16.4 (G), Z17.4 (G), Z18.4 (G)
GRN8: R9.5, Z29.4 (G), Z30.4 (G), Z31.4 (G), Z32.4 (G), Z33.4 (G), Z34.4 (G), Z35.4 (G), Z36.4 (G), Z101.4 (G), Z102.4 (G)
GRN9: R10.7, Z46.4 (G), Z47.4 (G), Z48.4 (G), Z49.4 (G), Z50.4 (G), Z51.4 (G), Z52.4 (G), Z53.4 (G), Z54.4 (G), Z103.4 (G)
GRN10: R10.5, Z64.4 (G), Z65.4 (G), Z66.4 (G), Z67.4 (G), Z68.4 (G), Z69.4 (G), Z70.4 (G)
GRN11: R11.7, Z79.4 (G), Z80.4 (G), Z81.4 (G), Z82.4 (G), Z83.4 (G), Z84.4 (G), Z85.4 (G), Z86.4 (G), Z87.4 (G)
GRN12: R11.5, Z92.4 (G), Z93.4 (G), Z94.4 (G), Z95.4 (G), Z96.4 (G), Z97.4 (G), Z98.4 (G), Z99.4 (G)
LED1: U5.11 (SW11), Z1.1 (A), Z19.1 (A), Z37.1 (A), Z55.1 (A), Z71.1 (A), Z88.1 (A)
LED1_CS: U5.25 (CS); also elsewhere on the board
LED2: U5.10 (SW9), Z20.1 (A), Z89.1 (A)
LED2_CS: U6.25 (CS); also elsewhere on the board
LED3: U5.9 (SW7), Z2.1 (A), Z21.1 (A), Z38.1 (A), Z56.1 (A), Z72.1 (A), Z90.1 (A)
LED4: U5.8 (SW5), Z3.1 (A), Z22.1 (A), Z39.1 (A), Z57.1 (A), Z73.1 (A), Z104.1 (A)
LED5: U5.7 (SW3), Z4.1 (A), Z23.1 (A), Z40.1 (A), Z58.1 (A), Z74.1 (A), Z105.1 (A)
LED6: U5.6 (SW1), Z5.1 (A), Z24.1 (A), Z41.1 (A), Z59.1 (A), Z75.1 (A), Z91.1 (A)
LED7: U5.4 (SW2), Z6.1 (A), Z25.1 (A), Z42.1 (A), Z60.1 (A), Z76.1 (A), Z106.1 (A)
LED8: U5.3 (SW4), Z7.1 (A), Z26.1 (A), Z43.1 (A), Z61.1 (A), Z77.1 (A), Z107.1 (A)
LED9: U5.2 (SW6), Z8.1 (A), Z27.1 (A), Z44.1 (A), Z62.1 (A), Z78.1 (A)
LED10: U5.1 (SW8), Z9.1 (A), Z28.1 (A), Z45.1 (A), Z63.1 (A)
LED11: U6.11 (SW11), Z10.1 (A), Z29.1 (A), Z46.1 (A), Z64.1 (A), Z79.1 (A), Z92.1 (A)
LED12: U6.10 (SW9), Z11.1 (A), Z30.1 (A), Z47.1 (A), Z65.1 (A), Z80.1 (A), Z93.1 (A)
LED13: U6.9 (SW7), Z12.1 (A), Z31.1 (A), Z48.1 (A), Z66.1 (A), Z81.1 (A), Z94.1 (A)
LED14: U6.8 (SW5), Z13.1 (A), Z32.1 (A), Z49.1 (A), Z67.1 (A), Z95.1 (A)
LED15: U6.7 (SW3), Z50.1 (A), Z82.1 (A), Z96.1 (A), Z101.1 (A)
LED16: U6.6 (SW1), Z14.1 (A), Z83.1 (A), Z97.1 (A), Z102.1 (A), Z103.1 (A)
LED17: U6.4 (SW2), Z15.1 (A), Z33.1 (A), Z51.1 (A), Z68.1 (A), Z84.1 (A)
LED18: U6.3 (SW4), Z16.1 (A), Z34.1 (A), Z52.1 (A), Z69.1 (A), Z85.1 (A), Z98.1 (A)
LED19: U6.2 (SW6), Z17.1 (A), Z35.1 (A), Z53.1 (A), Z70.1 (A), Z86.1 (A), Z99.1 (A)
LED20: U6.1 (SW8), Z18.1 (A), Z36.1 (A), Z54.1 (A), Z87.1 (A)
LED_PWR_EN: C5.2, C10.2, R37.2, R39.2, TP-LED-EN.1, U5.26 (SDB), U6.26 (SDB), U7.3 (ON), U8.3 (ON); also elsewhere on the board
MISO: U5.24 (MISO), U6.24 (MISO); also elsewhere on the board
MOSI: U5.28 (MOSI), U6.28 (MOSI); also elsewhere on the board
unnamed: R72.2, U8.6 (RT)
unnamed: R71.2, U7.6 (RT)
unnamed: R38.2, U5.29 (ISET)
unnamed: R40.2, U6.29 (ISET)
RED1: R12.8, Z1.3 (R), Z2.3 (R), Z3.3 (R), Z4.3 (R), Z5.3 (R), Z6.3 (R), Z7.3 (R), Z8.3 (R), Z9.3 (R)
RED2: R12.7, Z19.3 (R), Z20.3 (R), Z21.3 (R), Z22.3 (R), Z23.3 (R), Z24.3 (R), Z25.3 (R), Z26.3 (R), Z27.3 (R), Z28.3 (R)
RED3: R12.6, Z37.3 (R), Z38.3 (R), Z39.3 (R), Z40.3 (R), Z41.3 (R), Z42.3 (R), Z43.3 (R), Z44.3 (R), Z45.3 (R)
RED4: R13.7, Z55.3 (R), Z56.3 (R), Z57.3 (R), Z58.3 (R), Z59.3 (R), Z60.3 (R), Z61.3 (R), Z62.3 (R), Z63.3 (R)
RED5: R13.6, Z71.3 (R), Z72.3 (R), Z73.3 (R), Z74.3 (R), Z75.3 (R), Z76.3 (R), Z77.3 (R), Z78.3 (R)
RED6: R13.5, Z88.3 (R), Z89.3 (R), Z90.3 (R), Z91.3 (R), Z104.3 (R), Z105.3 (R), Z106.3 (R), Z107.3 (R)
RED7: R14.8, Z10.3 (R), Z11.3 (R), Z12.3 (R), Z13.3 (R), Z14.3 (R), Z15.3 (R), Z16.3 (R), Z17.3 (R), Z18.3 (R)
RED8: R14.7, Z29.3 (R), Z30.3 (R), Z31.3 (R), Z32.3 (R), Z33.3 (R), Z34.3 (R), Z35.3 (R), Z36.3 (R), Z101.3 (R), Z102.3 (R)
RED9: R14.6, Z46.3 (R), Z47.3 (R), Z48.3 (R), Z49.3 (R), Z50.3 (R), Z51.3 (R), Z52.3 (R), Z53.3 (R), Z54.3 (R), Z103.3 (R)
RED10: R15.5, Z64.3 (R), Z65.3 (R), Z66.3 (R), Z67.3 (R), Z68.3 (R), Z69.3 (R), Z70.3 (R)
RED11: R15.7, Z79.3 (R), Z80.3 (R), Z81.3 (R), Z82.3 (R), Z83.3 (R), Z84.3 (R), Z85.3 (R), Z86.3 (R), Z87.3 (R)
RED12: R15.6, Z92.3 (R), Z93.3 (R), Z94.3 (R), Z95.3 (R), Z96.3 (R), Z97.3 (R), Z98.3 (R), Z99.3 (R)
SCK: U5.27 (SCK), U6.27 (SCK); also elsewhere on the board
SCL: R42.1; also elsewhere on the board
SDA: R41.1; also elsewhere on the board
SYNC: U5.30 (SYNC), U6.30 (SYNC)
VCC_1: C33.2, C34.2, U7.1 (BI), U7.2 (IN), U8.1 (BI), U8.2 (IN); also elsewhere on the board
VCC_2: R41.2, R42.2; also elsewhere on the board
VCC_LED_1: C1.2, C2.2, C3.2, C4.2, TP-V-LED-1.1, U5.5 (PVCC), U5.22 (VCC), U7.5 (OUT)
VCC_LED_2: C6.2, C7.2, C8.2, C9.2, TP-V-LED-2.1, U6.5 (PVCC), U6.22 (VCC), U8.5 (OUT)
XB1: R6.1, U5.39 (CS1)
XB2: R6.3, U5.36 (CS4)
XB3: R7.3, U5.33 (CS7)
XB4: R7.1, U5.21 (CS10)
XB5: R8.1, U5.18 (CS13)
XB6: R8.3, U5.14 (CS16)
XB7: R9.1, U6.39 (CS1)
XB8: R9.3, U6.36 (CS4)
XB9: R10.1, U6.33 (CS7)
XB10: R10.3, U6.21 (CS10)
XB11: R11.1, U6.18 (CS13)
XB12: R11.3, U6.14 (CS16)
XG1: R6.2, U5.38 (CS2)
XG2: R6.4, U5.35 (CS5)
XG3: R7.4, U5.32 (CS8)
XG4: R7.2, U5.20 (CS11)
XG5: R8.2, U5.17 (CS14)
XG6: R8.4, U5.13 (CS17)
XG7: R9.2, U6.38 (CS2)
XG8: R9.4, U6.35 (CS5)
XG9: R10.2, U6.32 (CS8)
XG10: R10.4, U6.20 (CS11)
XG11: R11.2, U6.17 (CS14)
XG12: R11.4, U6.13 (CS17)
XR1: R12.1, U5.37 (CS3)
XR2: R12.2, U5.34 (CS6)
XR3: R12.3, U5.31 (CS9)
XR4: R13.2, U5.19 (CS12)
XR5: R13.3, U5.15 (CS15)
XR6: R13.4, U5.12 (CS18)
XR7: R14.1, U6.37 (CS3)
XR8: R14.2, U6.34 (CS6)
XR9: R14.3, U6.31 (CS9)
XR10: R15.4, U6.19 (CS12)
XR11: R15.2, U6.15 (CS15)
XR12: R15.3, U6.12 (CS18)

Notes on the sheet:
DNP / Not Used I2C Pull-up
LED POWER SWITCHES
CHARLIE PIXEL DRIVERS

Board: 2 copper layers, 369.1 x 121.4 mm, 464 parts (334 on the bottom side), 281 nets.

Other parts of the board:
U$6: TECSMITH-LOGOLONG; TECSMITH-NAME

## EAGLE design EAGLE/vr99/dip-switch-daughter-brd-revA.brd

Board: 2 copper layers, 40.0 x 9.0 mm, 9 parts (0 on the bottom side), 9 nets.

Parts:
D1, D2, D3, D4: SOD-123
DIP-SWITCH: DIP004; DIP-1.27-004
JDIP1: MOLEX_0781710006; MOLEX_781710006
U$1, U$2, U$7: FIDUCIAL

Connections:
COL3: DIP-SWITCH.4, JDIP1.3
COL4: DIP-SWITCH.3, JDIP1.4
COL6: DIP-SWITCH.2, JDIP1.5
COL7: DIP-SWITCH.1, JDIP1.6
unnamed: D1.A, DIP-SWITCH.5
unnamed: D2.A, DIP-SWITCH.6
unnamed: D3.A, DIP-SWITCH.7
unnamed: D4.A, DIP-SWITCH.8
ROW5: D1.C, D2.C, D3.C, D4.C, JDIP1.2

## EAGLE design EAGLE/north-btn-module/btn-module.brd

Parts:
J1: MOLEX_0781710004; MOLEX_781710004
SW_F17: MX-5-PIN-HOTSWAP-PAD
U$1: MOLEX_0781710006; MOLEX_781710006
Z17: 156120M173000

Connections:
5: U$1.5
6: U$1.6
GND: U$1.1
unnamed: J1.2, Z17.4 (G)
unnamed: SW_F17.2@1 (S), SW_F17.2@2 (S), U$1.3
unnamed: SW_F17.1@1, SW_F17.1@2, U$1.4
unnamed: J1.3, Z17.3 (R)
unnamed: J1.4, Z17.2 (B)
unnamed: J1.1, Z17.1 (A)

Board: 2 copper layers, 20.5 x 20.5 mm, 4 parts (3 on the bottom side), 6 nets.

## Code that names these connections

File cubemx/sr99-stm32g474-hotswap.ioc (part):

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Mcu.Name=STM32G474C(B-C-E)Tx
Mcu.Package=LQFP48
Mcu.UserName=STM32G474CBTx
PA0.Mode=SYS_WakeUp0
PA0.Signal=SYS_WKUP1
PA1.GPIOParameters=GPIO_Label
PA1.GPIO_Label=MATRIX_CS
PA1.Signal=GPIO_Output
PA11.Mode=Device
PA11.Signal=USB_DM
PA12.Mode=Device
PA12.Signal=USB_DP
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.Mode=I2C
PA15.Signal=I2C1_SCL
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=EEPROM_CS
PA4.Signal=GPXTI4
PA5.Mode=Full_Duplex_Master
PA5.Signal=SPI1_SCK
PA6.Mode=Full_Duplex_Master
PA6.Signal=SPI1_MISO
PA7.Mode=Full_Duplex_Master
PA7.Signal=SPI1_MOSI
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=LED2_CS
PB0.Signal=GPIO_Output
PB1.GPIOParameters=GPIO_Label
PB1.GPIO_Label=LED1_CS
PB1.Signal=GPIO_Output
PB10.GPIOParameters=GPIO_Label
PB10.GPIO_Label=ROW0
PB10.Signal=GPIO_Output
PB11.GPIOParameters=GPIO_Label
PB11.GPIO_Label=ROW1
PB11.Signal=GPIO_Output
PB12.GPIOParameters=GPIO_Label
PB12.GPIO_Label=ROW2
PB12.Signal=GPIO_Output
PB13.GPIOParameters=GPIO_Label
PB13.GPIO_Label=ROW3
PB13.Signal=GPIO_Output
PB14.GPIOParameters=GPIO_Label
PB14.GPIO_Label=ROW4
PB14.Signal=GPIO_Output
PB15.GPIOParameters=GPIO_Label
PB15.GPIO_Label=ROW5
PB15.Signal=GPIO_Output
PB2.GPIOParameters=GPIO_Label
PB2.GPIO_Label=LED_NL
PB2.Signal=GPIO_Output
PB3.Signal=SYS_JTDO-SWO
PB4.Mode=Sink_AllSignals
PB4.Signal=UCPD1_CC2
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=LED_CL
PB5.Signal=GPIO_Output
PB6.Mode=Sink_AllSignals
PB6.Signal=UCPD1_CC1
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
PB8-BOOT0.GPIOParameters=GPIO_Label
PB8-BOOT0.GPIO_Label=BOOT0
PB8-BOOT0.Signal=GPIO_Input
PC13.GPIOParameters=GPIO_Label
PC13.GPIO_Label=LED_PWR_EN
PC13.Signal=GPIO_Output
PF0-OSC_IN.Mode=HSE-External-Oscillator
PF0-OSC_IN.Signal=RCC_OSC_IN
PF1-OSC_OUT.Mode=HSE-External-Oscillator
PF1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=16000000
board=custom

File cubemx/vr98.ioc (part):

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Mcu.Name=STM32F411C(C-E)Ux
Mcu.Package=UFQFPN48
Mcu.UserName=STM32F411CEUx
PA11.Mode=Device_Only
PA11.Signal=USB_OTG_FS_DM
PA12.Mode=Device_Only
PA12.Signal=USB_OTG_FS_DP
PA2.Signal=GPIO_Input
PA3.Signal=GPIO_Input
PA5.Mode=Full_Duplex_Master
PA5.Signal=SPI1_SCK
PA6.Mode=Full_Duplex_Master
PA6.Signal=SPI1_MISO
PA7.Mode=Full_Duplex_Master
PA7.Signal=SPI1_MOSI
PA8.Signal=S_TIM1_CH1
PB6.Mode=I2C
PB6.Signal=I2C1_SCL
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
RCC.HSE_VALUE=25000000
RCC.SYSCLKFreq_VALUE=16000000
board=custom

## Commit log

2022-10-31 intent uploaded
2023-02-14 Added 1800 variant
2023-03-24 initial sch
2023-03-25 docs
2023-03-26 added LED matrix
2023-03-26 led matrix done
2023-03-27 more docs
2023-03-30 move to ISP LED driver
2023-03-30 update to docs
2023-05-19 parking the north variant for now
2023-05-19 add the south variant
2024-09-23 update to docs, images
2024-09-24 pre- GND routing save
2024-09-24 post GND-routing save
2024-09-26 DIP Switch DB
2024-09-26 Beta 1
2024-09-27 Added "ground to boot" function
2024-09-28 Self-criticism
2024-11-06 confirmed m2 mounting points
2025-11-15 Remove EAGLE files & update docs
2025-11-15 wip-2025-11-15
2025-11-17 wip-2025-11-17
2025-11-19 FIle rename
2025-11-19 Docs cleanup
2025-11-19 wip-2025-11-19
2025-11-20 update-2025-11-20
2025-11-24 wip-2025-11-23
2026-06-10 pre-DRC upload
2026-06-11 ready to order
2026-06-11 removed stepped caps-lock
2026-06-15 Added Tag-Connect EC-06
2026-06-18 move folder
2026-06-21 updated some kb footprints
